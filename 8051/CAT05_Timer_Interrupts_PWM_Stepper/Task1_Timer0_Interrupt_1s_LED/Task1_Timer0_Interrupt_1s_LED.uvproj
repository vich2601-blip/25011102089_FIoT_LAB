# Keil uVision project Task1_Timer0_Interrupt_1s_LED.uvproj, settings and files
target AT89S52 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODP2
  output: Task1_Timer0_Interrupt_1s_LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 main.c
