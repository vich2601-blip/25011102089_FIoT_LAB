# Keil uVision project TaskC_Interrupt_Driven_RX_Ring_Buffer.uvproj, settings and files
target AT89S52 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODP2
  output: TaskC_Interrupt_Driven_RX_Ring_Buffer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 main.c uart.c uart.h
